# Keil uVision project ECHO.uvprojx, settings and files
target ECHO (6210000::V6.21::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G1X0X_G3X0X_DFP.1.3.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20100000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) XRAM(0x20200000,0x00008000) XRAM2(0x20300000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: ECHO +hex
  BeforeMake: cmd.exe /C "$P..\tools\syscfg_echo.cmd"
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0G3507__
  c include: ..\app;..\app\tasks;..\app\ui;..\bsp\include;..\module\control;..\module\device;..\module\service;..\config;..\platform\freertos;..\platform\generated;..\freertos;D:\sftoware\TI_CCS\mspm0_sdk_2_10_00_04\source\third_party\CMSIS\Core\Include;D:\sftoware\TI_CCS\mspm0_sdk_2_10_00_04\kernel\freertos\Source\include;D:\sftoware\TI_CCS\mspm0_sdk_2_10_00_04\source;D:\sftoware\TI_CCS\mspm0_sdk_2_10_00_04\kernel\freertos\Source\portable\GCC\ARM_CM0
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT6: ROM 0x20200000 size 0x8000
  memory RVCT7: ROM 0x20300000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x8000
  scatter file: .\mspm0g3507.sct
  link misc: D:\sftoware\TI_CCS\mspm0_sdk_2_10_00_04\source\ti\driverlib\lib\keil\m0p\mspm0g1x0x_g3x0x\driverlib.a ..\freertos\keil\Objects\freertos_ECHO.lib
  group Application
    ../app/: main.c
    ../app/tasks/: app_tasks.c display_task.c system_task.c service_task.c
    ../app/ui/: ui_input.c diagnostic_page.c competition_page.c
    ../module/device/: ssd1306.c tfmini_s.c mpu6050.c zdt_protocol.c zdt_stepper.c ball_vision.c line_follower_6ch.c
    ../module/service/: serial_tx.c telemetry.c serial_rx.c esp_uart_link_test.c command_service.c motor_profile.c parameter_service.c competition_service.c h_mission_service.c ball_balance_service.c competition_storage.c system_health.c imu_service.c attitude_estimator.c chassis_actuator.c
    ../module/control/: wheel_speed_controller.c heading_controller.c distance_controller.c ball_position_controller.c
  group BSP
    ../bsp/source/: bsp_led.c bsp_buttons.c bsp_time.c bsp_encoder.c bsp_motor.c bsp_reset.c bsp_uart_tx_dma.c bsp_esp_uart.c bsp_tfmini_uart.c bsp_i2c.c bsp_reflectance.c bsp_supply_voltage.c bsp_zdt_uart.c
  group Platform
    ../config/: ECHO.syscfg
    ./: startup_mspm0g350x_uvision.s
    ../platform/generated/: ti_msp_dl_config.h ti_msp_dl_config.c
    ../platform/freertos/: rtos_diagnostics.c rtos_hooks.c
