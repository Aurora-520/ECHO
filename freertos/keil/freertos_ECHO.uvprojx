# Keil uVision project freertos_ECHO.uvprojx, settings and files
target freertos_ECHO (6160000::V6.16::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G1X0X_G3X0X_DFP.1.3.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20200000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: freertos_ECHO +hex (library)
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3
  c define: __MSPM0G3507__
  c include: D:\sftoware\TI_CCS\mspm0_sdk_2_10_00_04\source;D:\sftoware\TI_CCS\mspm0_sdk_2_10_00_04\source\third_party\CMSIS\Core\Include;D:\sftoware\TI_CCS\mspm0_sdk_2_10_00_04\kernel\freertos\Source\include;D:\sftoware\TI_CCS\mspm0_sdk_2_10_00_04\kernel\freertos\Source\portable\GCC\ARM_CM0;..
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20200000 size 0x8000
  group Header files
    ../: FreeRTOSConfig.h
  group Source files
    D:/sftoware/TI_CCS/mspm0_sdk_2_10_00_04/kernel/freertos/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    D:/sftoware/TI_CCS/mspm0_sdk_2_10_00_04/kernel/freertos/Source/portable/MemMang/: heap_4.c
    D:/sftoware/TI_CCS/mspm0_sdk_2_10_00_04/kernel/freertos/Source/portable/GCC/ARM_CM0/: port.c portasm.c
    D:/sftoware/TI_CCS/mspm0_sdk_2_10_00_04/kernel/freertos/dpl/: ClockP_freertos.c DebugP_freertos.c MutexP_freertos.c SemaphoreP_freertos.c SystemP_freertos.c TaskP_freertos.c HwiPMSPM0_freertos.c
    D:/sftoware/TI_CCS/mspm0_sdk_2_10_00_04/source/ti/devices/msp/m0p/startup_system_files/keil/: startup_mspm0g350x_uvision.s
